# Keil uVision project Mini_project.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: Mini_project +hex
  AfterMake: D:\kek\8051_AURO_2024\Mini-Project\EXE\hex2bin.exe .\Objects\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include;.\Library
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./Common/: Common.c Delay.c
    ./Library/: LCD_2_Wire.c PCF8574.c SW_I2C.c Relay.c
